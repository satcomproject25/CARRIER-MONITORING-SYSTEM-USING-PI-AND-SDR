options:
  parameters:
    author: SATCOM
    generate_options: qt_gui
    id: sdr_scipy
    output_language: python
    title: sdr_scipy
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 70e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: fft_size
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    type: complex
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: TX/RX
    balance0: '0'
    bw0: samp_rate
    center_freq0: freq
    correction0: '0'
    dc_offset0: 'False'
    dc_removal0: 'False'
    devname: hackrf
    overall_gain0: '20.6'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
